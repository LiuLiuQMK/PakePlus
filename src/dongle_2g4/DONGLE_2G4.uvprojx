# Keil uVision project DONGLE_2G4.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M4") FPU2 CLOCK(12800000) ELITTLE
  output: DONGLE_2G4 +hex
  AfterMake: fromelf.exe --bin -o DONGLE_2G4.bin ./output/DONGLE_2G4.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: sdk/bundles/noos_mini/inc;sdk/bundles/noos_mini/inc/os;sdk/src/BSP;sdk/src/FWlib;sdk/src/StartUP/ing916;sdk/src/Tools;sdk/src;.\src;.\src\2P4G;.\src\common;.\src\IAP;.\src\IAP_BSP;.\src\APP_STORAGE;.\src\app_main_loop;.\src\Ctrl
  library: MicroLIB
  memory RVCT4: ROM 0x2027000 size 0x59000
  memory RVCT9: RAM 0x20004360 size 0x9ca0
  group APP
    ./src/: main.c profile.c noos_impl.c my_irq.c uart_console.c
  group StartUP
    ./src/: startup_ing91600.s
    sdk/bundles/noos_mini/ING9168xx/: symdefs.m
  group BSP
    sdk/src/BSP/: eflash.c
  group FWlib
    sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_comparator.c peripheral_dma.c peripheral_efuse.c peripheral_i2s.c peripheral_ir.c peripheral_keyscan.c peripheral_pdm.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
  group Tools
    sdk/src/Tools/: trace.c
  group 2G4_Lib
    ./src/2P4G/: BLE_2P4G_Switch.lib
  group app_mode
    ./src/2P4G/: app_2g4.c
  group common
    ./src/common/: crc16.c
  group IAP
    ./src/IAP/: IAP_916.c IAP_Application.c IAP_Bootloader.c IAP_Flash_WP.c IAP_Transport.c
  group IAP_BSP
    ./src/IAP_BSP/: bsp_usb_hid_iap.c
  group Ctrl
    ./src/Ctrl/: ctrl.c
  group app stroage
    ./src/APP_STORAGE/: app_storage.c kv_impl.c
  group app_cus_loop
    ./src/app_main_loop/: cust_main.c
software components: CMSIS:CORE 4.3.0
